#include "ui_icons.h"
#include "display.h"
#include <stddef.h>

#define UI_ICON_SIZE   (8U)

static const uint8_t ui_icon_bitmap[UI_ICON_COUNT][UI_ICON_SIZE] =
{
  [UI_ICON_THERMO] =
    { 0x18U, 0x24U, 0x24U, 0x24U, 0x24U, 0x2CU, 0x3CU, 0x18U },
  [UI_ICON_BOLT] =
    { 0x06U, 0x0CU, 0x18U, 0x3FU, 0x06U, 0x0CU, 0x18U, 0x30U },
  [UI_ICON_PLUG] =
    { 0x66U, 0x66U, 0xFFU, 0xFFU, 0x7EU, 0x3CU, 0x18U, 0x00U },
  [UI_ICON_SNOW] =
    { 0x24U, 0x7EU, 0x24U, 0x18U, 0x18U, 0x24U, 0x7EU, 0x24U },
  [UI_ICON_TARGET] =
    { 0x3CU, 0x42U, 0x99U, 0xA5U, 0xA5U, 0x99U, 0x42U, 0x3CU },
  [UI_ICON_MODE] =
    { 0x3CU, 0x66U, 0x5AU, 0x5AU, 0x5AU, 0x5AU, 0x66U, 0x3CU },
  [UI_ICON_CHECK] =
    { 0x01U, 0x03U, 0x07U, 0x0EU, 0x5CU, 0x78U, 0x30U, 0x00U },
  [UI_ICON_WARN] =
    { 0x18U, 0x18U, 0x3CU, 0x3CU, 0x7EU, 0x7EU, 0xFFU, 0x00U },
  [UI_ICON_GEAR] =
    { 0x18U, 0x3CU, 0x7EU, 0xDBU, 0xDBU, 0x7EU, 0x3CU, 0x18U },
  [UI_ICON_SPEAKER] =
    { 0x0CU, 0x1CU, 0x3CU, 0x7CU, 0x7CU, 0x3CU, 0x1CU, 0x0CU },
  [UI_ICON_CLOCK] =
    { 0x3CU, 0x42U, 0x49U, 0x45U, 0x41U, 0x42U, 0x3CU, 0x00U },
  [UI_ICON_ARROW_RIGHT] =
    { 0x10U, 0x18U, 0x1CU, 0x1EU, 0x1EU, 0x1CU, 0x18U, 0x10U },
  [UI_ICON_UP_DOWN] =
    { 0x18U, 0x3CU, 0x18U, 0x00U, 0x18U, 0x3CU, 0x18U, 0x00U },
  [UI_ICON_POWER] =
    { 0x18U, 0x5AU, 0x5AU, 0x18U, 0x18U, 0x18U, 0x3CU, 0x00U },
  [UI_ICON_FLAME] =
    { 0x08U, 0x18U, 0x3CU, 0x7EU, 0x7EU, 0x3CU, 0x18U, 0x00U },
  [UI_ICON_CURVE] =
    { 0x02U, 0x04U, 0x08U, 0x10U, 0x20U, 0x40U, 0x7EU, 0x00U }
};

void ui_icon_draw(ui_icon_t icon, uint16_t x, uint16_t y, uint16_t color)
{
  uint8_t row;
  uint8_t col;
  uint8_t run;
  uint8_t bits;

  if(icon >= UI_ICON_COUNT)
  {
    return;
  }

  for(row = 0U; row < UI_ICON_SIZE; row++)
  {
    bits = ui_icon_bitmap[icon][row];
    col = 0U;

    while(col < UI_ICON_SIZE)
    {
      if((bits & (uint8_t)(0x80U >> col)) == 0U)
      {
        col++;
        continue;
      }

      run = 1U;

      while(((uint8_t)(col + run) < UI_ICON_SIZE) &&
            ((bits & (uint8_t)(0x80U >> (col + run))) != 0U))
      {
        run++;
      }

      display_fill_rect((uint16_t)(x + col), (uint16_t)(y + row),
                        run, 1U, color);
      col = (uint8_t)(col + run);
    }
  }
}
